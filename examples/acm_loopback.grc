options:
  parameters:
    author: Research - DVB-S2 ACM
    category: Custom
    copyright: GPLv3
    description: DVB-S2 ACM full loopback with physics-based LEO satellite channel
    generate_options: qt_gui
    id: acm_loopback
    output_language: python
    title: DVB-S2 ACM Loopback — LEO Satellite Channel
  states: {}

blocks:
- name: altitude_km
  id: variable
  parameters:
    comment: LEO orbital altitude (km) — restart flowgraph to apply
    value: '500.0'
  states: {}
- name: samps_per_sym
  id: variable
  parameters:
    comment: Oversampling rate — 2 samples per symbol for RRC pulse shaping
    value: '2'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    comment: Root-Raised-Cosine filter taps (rolloff=0.20, 45 taps)
    value: firdes.root_raised_cosine(1.0, samps_per_sym, 1.0, 0.20, 45)
  states: {}
- name: noise_amp
  id: variable
  parameters:
    value: 10**(-snr_db/20.0)
  states: {}
- name: rain_rate
  id: variable
  parameters:
    comment: Rain rate (mm/hr) — 0=clear sky, 5=light, 25=heavy
    value: '5.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    label: AWGN Noise Floor (dB) — LEO fading handled by channel block
    start: '20'
    step: '1'
    stop: '40'
    value: '30'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '188000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: Prints MODCOD decisions to console
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    comment: Prints LEO channel state (SNR, elevation, Doppler, RTT) to console
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate * samps_per_sym
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    comment: AWGN background noise only — LEO fading is in dvbs2acm_leo_channel_0
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_amp
    seed: '0'
    taps: 1.0+0j
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: |-
      Frequency-Locked Loop (FLL) — modulation-agnostic Doppler correction.
      Works for ALL DVB-S2 MODCODs (QPSK/8PSK/16APSK/32APSK).
      Locks on spectral band-edges (rolloff region), not the constellation.
      PL Sync handles residual fine phase recovery via SOF + pilots.
    filter_size: '45'
    rolloff: '0.20'
    samps_per_sym: samps_per_sym
    type: cc
    w: '0.01'
  states: {}
- name: dvbs2acm_acm_controller_0
  id: dvbs2acm_acm_controller
  parameters:
    acm_mode: dvbs2acm.AcmMode.ACM
    ai_socket: '"tcp://localhost:5557"'
    frame_size: dvbs2acm.FrameSize.NORMAL
    history_len: '16'
    hysteresis_db: '0.3'
    initial_modcod: '4'
    snr_margin_db: '1.0'
    target_ber: '1e-7'
    use_ai: 'True'
  states: {}
- name: dvbs2acm_acm_feedback_0
  id: dvbs2acm_acm_feedback
  parameters:
    ber_alpha: '0.05'
    report_period_ms: '100.0'
    snr_alpha: '0.1'
  states: {}
- name: dvbs2acm_bb_framer_acm_0
  id: dvbs2acm_bb_framer_acm
  parameters:
    frame_size: dvbs2acm.FrameSize.NORMAL
    initial_modcod: '4'
    pilots: 'True'
    stream_type: dvbs2acm.StreamType.TRANSPORT
  states: {}
- name: dvbs2acm_demodulator_acm_0
  id: dvbs2acm_demodulator_acm
  parameters:
    initial_modcod: '4'
    noise_var: '0.1'
  states: {}
- name: dvbs2acm_fec_decoder_acm_0
  id: dvbs2acm_fec_decoder_acm
  parameters:
    frame_size: dvbs2acm.FrameSize.NORMAL
    initial_modcod: '4'
    ldpc_algorithm: dvbs2acm.LdpcAlgorithm.ONESIDE
    max_iter: '20'
  states: {}
- name: dvbs2acm_fec_encoder_acm_0
  id: dvbs2acm_fec_encoder_acm
  parameters:
    frame_size: dvbs2acm.FrameSize.NORMAL
    initial_modcod: '4'
    ldpc_algorithm: dvbs2acm.LdpcAlgorithm.ONESIDE
  states: {}
- name: dvbs2acm_leo_channel_0
  id: dvbs2acm_leo_channel
  parameters:
    altitude_km: altitude_km
    comment: 'Physics-based LEO channel: Doppler + path loss + rain + Rician fading'
    freq_hz: 8.025e9
    min_elevation_deg: '5.0'
    noise_temp_k: '150.0'
    rain_rate_mm_hr: rain_rate
    rx_gain_dbi: '40.0'
    sample_rate: samp_rate * samps_per_sym
    tx_gain_dbi: '35.0'
    tx_power_dbw: '20.0'
    update_period_ms: '100.0'
  states: {}
- name: dvbs2acm_modulator_acm_0
  id: dvbs2acm_modulator_acm
  parameters:
    initial_modcod: '4'
    rolloff: '0.20'
  states: {}
- name: dvbs2acm_pl_framer_acm_0
  id: dvbs2acm_pl_framer_acm
  parameters:
    initial_modcod: '4'
    pilots: 'True'
    rolloff: '0.20'
  states: {}
- name: dvbs2acm_pl_sync_acm_0
  id: dvbs2acm_pl_sync_acm
  parameters:
    avg_frames: '4'
    threshold: '0.7'
  states: {}
- name: dvbs2acm_snr_estimator_0
  id: dvbs2acm_snr_estimator
  parameters:
    avg_frames: '4'
    estimator_type: dvbs2acm.SnrEstimatorType.HYBRID
    frame_size: dvbs2acm.FrameSize.NORMAL
    kalman_filter: 'True'
    pilots: 'True'
    report_period: '8'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: Post-FLL IQ
    name: '"RX Constellation (Post-FLL)"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate * samps_per_sym
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: TX Spectrum
    label2: RX Spectrum
    name: '"DVB-S2 Spectrum"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    alpha2: '0.8'
    average: '0.2'
    bw: samp_rate * samps_per_sym
    comment: 'Pre-Costas vs Post-Costas spectrum: red shift = uncorrected Doppler, blue = after carrier recovery'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,2,1,2
    label1: Pre-Costas (raw)
    label2: Post-FLL
    name: '"Carrier Recovery: Pre vs Post FLL (Doppler Correction)"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.6'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,2,1,1
    label1: Real
    label2: Imag
    name: '"TX IQ Waveform"'
    size: '1024'
    srate: samp_rate * samps_per_sym
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate * samps_per_sym
    comment: LEO Doppler waterfall — watch carrier shift ±188 kHz across the pass (AOS→TCA→LOS visible as chevron pattern)
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,1,2
    name: '"LEO Doppler Waterfall (AOS\u2192TCA\u2192LOS)"'
    type: complex
  states: {}
- name: filter_interp_fir_filter_xxx_0
  id: filter_interp_fir_filter_xxx
  parameters:
    comment: TX RRC pulse shaping — interpolates by 2, applies root-raised-cosine (rolloff=0.20). Limits spectral occupancy to symbol rate × (1+rolloff).
    interp: samps_per_sym
    samp_delay: '0'
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: 'RX matched RRC filter + symbol timing recovery (polyphase filterbank). Input: 2 sps  |  Output: 1 sps (1 clean sample per symbol). After this block the constellation shows standard DVB-S2 points.'
    filter_size: '32'
    init_phase: '16'
    max_rate_deviation: '1.5'
    osps: '1'
    sps: samps_per_sym
    taps: rrc_taps
    type: ccf
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: DVB-S2 recovered symbol constellation after RRC matched filter + timing recovery. Should show QPSK (4 pts), 8PSK (8 pts), 16APSK (16 pts) or 32APSK (32 pts) depending on current MODCOD selected by ACM/DQN.
    grid: 'True'
    gui_hint: 1,2,1,2
    label1: Recovered Symbols
    name: '"DVB-S2 Recovered Constellation (Post-Timing-Recovery)"'
    size: '4096'
    type: complex
  states: {}

connections:
- [analog_random_source_x_0, '0', dvbs2acm_bb_framer_acm_0, '0']
- [blocks_throttle2_0, '0', dvbs2acm_leo_channel_0, '0']
- [channels_channel_model_0, '0', digital_fll_band_edge_cc_0, '0']
- [channels_channel_model_0, '0', dvbs2acm_snr_estimator_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_1, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_1, '1']
- [digital_pfb_clock_sync_xxx_0, '0', dvbs2acm_pl_sync_acm_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_2, '0']
- [dvbs2acm_acm_controller_0, modcod_out, blocks_message_debug_0, print]
- [dvbs2acm_acm_controller_0, modcod_out, dvbs2acm_bb_framer_acm_0, modcod_in]
- [dvbs2acm_acm_controller_0, stats_out, blocks_message_debug_0, store]
- [dvbs2acm_acm_feedback_0, feedback_out, dvbs2acm_acm_controller_0, snr_in]
- [dvbs2acm_bb_framer_acm_0, '0', dvbs2acm_fec_encoder_acm_0, '0']
- [dvbs2acm_demodulator_acm_0, '0', dvbs2acm_fec_decoder_acm_0, '0']
- [dvbs2acm_fec_decoder_acm_0, '0', blocks_null_sink_0, '0']
- [dvbs2acm_fec_decoder_acm_0, ber_out, dvbs2acm_acm_feedback_0, ber_in]
- [dvbs2acm_fec_encoder_acm_0, '0', dvbs2acm_modulator_acm_0, '0']
- [dvbs2acm_leo_channel_0, '0', channels_channel_model_0, '0']
- [dvbs2acm_modulator_acm_0, '0', dvbs2acm_pl_framer_acm_0, '0']
- [dvbs2acm_modulator_acm_0, '0', qtgui_const_sink_x_1, '0']
- [dvbs2acm_pl_framer_acm_0, '0', filter_interp_fir_filter_xxx_0, '0']
- [filter_interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [dvbs2acm_pl_sync_acm_0, '0', dvbs2acm_demodulator_acm_0, '0']
- [dvbs2acm_pl_sync_acm_0, '0', qtgui_freq_sink_x_0, '1']
- [dvbs2acm_snr_estimator_0, snr_out, dvbs2acm_acm_feedback_0, snr_in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
