options:
  parameters:
    author: Pasindu Manujaya
    description: 'DVB-S2 ACM Closed-Loop Software Simulation. Full TX -> LEO Channel -> AWGN -> RX -> ACM Controller -> feedback loop entirely in software. Architecture: Random Source -> BB Framer -> FEC Encoder -> Modulator -> PL Framer -> Throttle -> LEO Channel -> AWGN Channel -> PL Sync -> SNR Estimator -> Demodulator -> FEC Decoder -> ACM Feedback -> ACM Controller -> BB Framer (loopback).'
    generate_options: qt_gui
    id: acm_loopback
    output_language: python
    title: DVB-S2 ACM Loopback Simulation
  states: {}

blocks:
- name: initial_modcod
  id: variable
  parameters:
    comment: QPSK 1/2 = safe initial MODCOD
    value: '4'
  states: {}
- name: rain_rate
  id: variable_qtgui_range
  parameters:
    comment: Rain attenuation slider (ITU-R P.618-13)
    gui_hint: tab@0:1,0,1,2
    label: Rain Rate (mm/hr)
    start: '0'
    step: '1'
    stop: '50'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample rate = symbol rate
    value: symbol_rate
  states: {}
- name: snr_db
  id: variable_qtgui_range
  parameters:
    comment: AWGN noise level. Measured SNR = snr_db - 16.6 dB at TCA.
    gui_hint: tab@0:0,0,1,2
    label: SNR (dB)
    start: '20'
    step: '0.5'
    stop: '50'
    value: '33'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    comment: 5 Msps DVB-S2 symbol rate
    value: 5e6
  states: {}
- name: acm_controller
  id: dvbs2acm_acm_controller
  parameters:
    acm_mode: dvbs2acm.AcmMode.ACM
    ai_socket: '"tcp://localhost:5557"'
    comment: 'ACM DECISION BLOCK. Selects optimal MODCOD based on measured SNR+BER. modcod_out → BB Framer modcod_in = loopback feedback (simulated return channel). Enable AI/ML: start acm_controller_ai.py then set use_ai=True.'
    frame_size: dvbs2acm.FrameSize.NORMAL
    history_len: '16'
    hysteresis_db: '0.5'
    initial_modcod: initial_modcod
    snr_margin_db: '1.0'
    target_ber: '1e-7'
    use_ai: 'True'
  states: {}
- name: acm_feedback
  id: dvbs2acm_acm_feedback
  parameters:
    ber_alpha: '0.05'
    comment: Aggregates SNR (from SNR Estimator) and BER/FER (from FEC Decoder) into a single feedback message for the ACM Controller.
    report_period_ms: '100.0'
    snr_alpha: '0.1'
  states: {}
- name: analog_random_source
  id: analog_random_source_x
  parameters:
    comment: Simulated transport stream data (MPEG-TS)
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: awgn_channel
  id: channels_channel_model
  parameters:
    comment: AWGN noise channel. Noise amplitude = 10^(-snr_db/20). Measured SNR at SNR Estimator = snr_db - 16.6 dB (signal chain power offset). Default snr_db=33 -> TCA SNR≈16.4 dB, AOS/LOS SNR≈4.2 dB.
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: bb_framer
  id: dvbs2acm_bb_framer_acm
  parameters:
    comment: 'TX: BB Framer. ACM Controller feeds MODCOD back here via modcod_in message port (loopback feedback = simulated return channel).'
    frame_size: dvbs2acm.FrameSize.NORMAL
    initial_modcod: initial_modcod
    pilots: 'True'
    stream_type: dvbs2acm.StreamType.TRANSPORT
  states: {}
- name: demodulator
  id: dvbs2acm_demodulator_acm
  parameters:
    comment: 'RX: soft-decision max-log LLR demodulation'
    initial_modcod: initial_modcod
    noise_var: '0.1'
  states: {}
- name: fec_decoder
  id: dvbs2acm_fec_decoder_acm
  parameters:
    comment: 'RX: iterative LDPC + BCH FEC decoding. Publishes BER/FER to ber_out.'
    frame_size: dvbs2acm.FrameSize.NORMAL
    initial_modcod: initial_modcod
    ldpc_algorithm: dvbs2acm.LdpcAlgorithm.ONESIDE
    max_iter: '20'
  states: {}
- name: fec_encoder
  id: dvbs2acm_fec_encoder_acm
  parameters:
    comment: 'TX: BCH outer + LDPC inner FEC encoder. All 28 MODCODs supported.'
    frame_size: dvbs2acm.FrameSize.NORMAL
    initial_modcod: initial_modcod
    ldpc_algorithm: dvbs2acm.LdpcAlgorithm.ONESIDE
  states: {}
- name: leo_channel
  id: dvbs2acm_leo_channel
  parameters:
    altitude_km: '500.0'
    comment: Physics-based LEO channel at 500 km, X-Band 8.025 GHz. Applies FSPL, Doppler (+/-188 kHz), rain, scintillation, Rician fading. Publishes channel_state messages.
    fading_coherence_s: '30.0'
    freq_hz: 8.025e9
    min_elevation_deg: '5.0'
    noise_temp_k: '150.0'
    rain_rate_mm_hr: rain_rate
    rx_gain_dbi: '37.0'
    sample_rate: samp_rate
    snr_offset_db: '0.0'
    time_acceleration: '10.0'
    tx_gain_dbi: '10.0'
    tx_power_dbw: '0.0'
    update_period_ms: '100.0'
  states: {}
- name: modulator
  id: dvbs2acm_modulator_acm
  parameters:
    comment: 'TX: constellation mapper (QPSK/8PSK/16APSK/32APSK). ACM-switched per frame.'
    initial_modcod: initial_modcod
    rolloff: '0.2'
  states: {}
- name: null_sink
  id: blocks_null_sink
  parameters:
    comment: Decoded data sink (replace with file sink or MPEG-TS demux for real use)
    type: byte
  states: {}
- name: orbit_visualizer
  id: dvbs2acm_orbit_visualizer
  parameters:
    altitude_km: '500.0'
    comment: 'Real-time two-tab visualizer: Sky View (polar plot) + Ground Track (world map).'
    gs_lat_deg: '0.0'
    gs_lon_deg: '0.0'
    pass_inclination_deg: '0.0'
    title: '"DVB-S2 ACM — LEO Pass Visualizer"'
  states: {}
- name: pl_framer
  id: dvbs2acm_pl_framer_acm
  parameters:
    comment: 'TX: PL Header (90 syms: SOF + PLSCODE), pilot blocks, Gold code scrambling'
    initial_modcod: initial_modcod
    pilots: 'True'
    rolloff: '0.20'
  states: {}
- name: pl_sync
  id: dvbs2acm_pl_sync_acm
  parameters:
    avg_frames: '4'
    comment: 'RX: SOF correlation, PLSCODE RM decoding, PLL, Gold descrambling. Tags output stream with detected MODCOD ID.'
    threshold: '0.7'
  states: {}
- name: qtgui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: 'Dual spectrum: pre-sync (blue) = AWGN output, post-sync (red) = PL Sync output. After lock both should be centred at DC.'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2:0,0,1,2
    label1: Pre-Sync (AWGN out)
    label2: Post-Sync (PL Sync out)
    name: '"DVB-S2 Spectrum (pre- vs post-PL Sync)"'
    nconnections: '2'
    tr_tag: ''
    type: complex
  states: {}
- name: qtgui_time_sink
  id: qtgui_time_sink_x
  parameters:
    comment: Signal amplitude vs time. Shows LEO fading and rain attenuation.
    gui_hint: tab@3:0,0,1,1
    label1: Signal Amplitude
    label2: ''
    name: '"Received Signal Envelope"'
    size: '1024'
    srate: samp_rate
    tr_tag: ''
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Scrolling spectrogram. Shows Doppler drift (spectrum shifts horizontally) and modulation changes.
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@3:0,1,1,1
    name: '"Waterfall (time-frequency)"'
    type: complex
  states: {}
- name: rx_constellation_sink
  id: qtgui_const_sink_x
  parameters:
    comment: RX Constellation after PL Sync (Panel 2). Spinning = not locked. Blobs = low SNR. Clean clusters = good link.
    gui_hint: tab@1:0,1,1,1
    label1: RX Constellation (PL Sync out)
    name: '"RX Signal (after PL Sync)"'
    size: '1024'
    tr_tag: ''
    type: complex
  states: {}
- name: snr_estimator
  id: dvbs2acm_snr_estimator
  parameters:
    avg_frames: '4'
    comment: 'RX: pilot-based SNR estimation (Hybrid MMSE/M2M4 + Kalman). Connected to raw AWGN output (before PL Sync) for channel-independent measurement.'
    estimator_type: dvbs2acm.SnrEstimatorType.HYBRID
    frame_size: dvbs2acm.FrameSize.NORMAL
    kalman_filter: 'True'
    pilots: 'True'
    report_period: '1'
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Control
    label1: Constellations
    label2: Spectrum
    label3: Time / Waterfall
    num_tabs: '4'
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    comment: Throttle to real-time symbol rate (prevents CPU overload in software loopback)
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: tx_constellation_sink
  id: qtgui_const_sink_x
  parameters:
    comment: TX Constellation before channel (Panel 1). Noiseless reference.
    gui_hint: tab@1:0,0,1,1
    label1: TX Constellation (Modulator out)
    name: '"TX Signal (before channel)"'
    size: '1024'
    tr_tag: ''
    type: complex
  states: {}

connections:
- [acm_controller, modcod_out, bb_framer, modcod_in]
- [acm_controller, modcod_out, orbit_visualizer, modcod_in]
- [acm_feedback, feedback_out, acm_controller, snr_in]
- [analog_random_source, '0', bb_framer, '0']
- [awgn_channel, '0', pl_sync, '0']
- [awgn_channel, '0', qtgui_freq_sink, '0']
- [awgn_channel, '0', qtgui_time_sink, '0']
- [awgn_channel, '0', qtgui_waterfall_sink, '0']
- [awgn_channel, '0', snr_estimator, '0']
- [bb_framer, '0', fec_encoder, '0']
- [demodulator, '0', fec_decoder, '0']
- [fec_decoder, '0', null_sink, '0']
- [fec_decoder, ber_out, acm_feedback, ber_in]
- [fec_encoder, '0', modulator, '0']
- [leo_channel, '0', awgn_channel, '0']
- [leo_channel, channel_state, acm_controller, channel_state_in]
- [leo_channel, channel_state, orbit_visualizer, channel_state_in]
- [modulator, '0', pl_framer, '0']
- [modulator, '0', tx_constellation_sink, '0']
- [pl_framer, '0', throttle, '0']
- [pl_sync, '0', demodulator, '0']
- [pl_sync, '0', qtgui_freq_sink, '1']
- [pl_sync, '0', rx_constellation_sink, '0']
- [snr_estimator, snr_out, acm_feedback, snr_in]
- [throttle, '0', leo_channel, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
